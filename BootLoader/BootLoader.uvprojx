# Keil uVision project BootLoader.uvprojx, settings and files
target BCM_Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HFxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BMS_BootloaderS32K +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_S32K144HFT0VLLT
  c include: .\Code\StartUp;.\Code\Interface;.\Code\Device;.\Code\Diagnose;.\Code\Module
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\Code\StartUp\BMS_bootLoader.sct
  group Startup
    ./Code/StartUp/: main.c system_S32K144.c startup_S32K144.s startup.c
  group Device
    ./Code/Device/: s32k144_lpuart.c pins_port_hw_access.c interrupt_manager.c clock_S32K1xx.c wdog_driver.c wdog_hw_access.c flexcan_driver.c flexcan_hw_access.c flexcan_irq.c osif_baremetal.c flash_driver.c edma_irq.c edma_hw_access.c edma_driver.c
  group Interface
    ./Code/Interface/: Interface.c UART.c Systick.c WatchDog.c CAN.c Flash.c Flash.h DMA.c PORT.c
  group Module
    ./Code/Module/: programming.c Bootloader.c Bootloader.h
  group Diagnose
    ./Code/Diagnose/: Diagnose_Communication.c Service.c FlyPDUNetwork.c
