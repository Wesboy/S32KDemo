# Keil uVision project S32K-demo.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144UFxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32k +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: -DCAR_SEL=CAR_NORMAL -DDEBUGMSG=1  -DAUDIO_CHIP=SAF775D_AUDIO
  c include: .\Device;.\interface;.\Startup;.\Startup\S32K144UFxxxLLx;.\Startup\Include;.\System\inc;.\Driver;.\Diagnose
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144UFxxxLLx\S32K144_64_flash.sct
  group interface
    ./interface/: interface.c interface.h UART.c UART.h I2C.c I2C.h ADC.c ADC.h FTM_PWM.h FlexCAN.c DMA.c DMA.h systick.c systick.h RTC.c RTC.h PORT.c PORT.h Watchdog.c Watchdog.h SPI.c FTM_InputCapture.c FTM_InputCapture.h SSD1306_flash.c SSD1306_flash.h SSD1306_OLED.c SSD1306_OLED.h FTM_PWM.c
  group startup
    ./Startup/: startup.c main.c
    ./Startup/S32K144/startup/: system_S32K144.c
    ./Startup/S32K144UFxxxLLx/: startup_S32K144.s
  group Device
    ./Device/: clock_manager.c clock_S32K1xx.c interrupt_manager.c osif_baremetal.c pins_port_hw_access.c s32k144_lpuart.c wdog_driver.c wdog_hw_access.c adc_driver.c lpi2c_driver.c lpi2c_hw_access.c lpi2c_irq.c pins_driver.c ftm_pwm_driver.c ftm_hw_access.c ftm_common.c rtc_driver.c rtc_hw_access.c flexcan_driver.c flexcan_hw_access.c flexcan_irq.c lpspi_hw_access.c lpspi_irq.c lpspi_master_driver.c lpspi_shared_function.c lpspi_slave_driver.c lptmr_hw_access.c lptmr_driver.c pdb_driver.c pdb_hw_access.c edma_irq.c edma_hw_access.c edma_driver.c lin_lpuart_driver.c lpuart_hw_access.c lpuart_driver.c lpuart_irq.c lin_common.c lin_driver.c lin_irq.c
  group System
    ./System/: can.c ipcEvent.c
target demodebug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144UFxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: as above
  output: S32k +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HEX_DEBUG
  c misc: -DCAR_SEL=CAR_NORMAL -DDEBUGMSG=1 -DHEX_DEBUG  -DAUDIO_CHIP=SAF775D_AUDIO
  c include: .\Device;.\interface;.\Startup;.\Startup\S32K144UFxxxLLx;.\Startup\Include;.\System\inc;.\Driver;.\Diagnose;.\FlyPDURouter
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144UFxxxLLx\S32K144_64_flash.sct
